v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 0 0 0 0 {name=p1 lab=clk}
C {devices/ipin.sym} 0 40 0 0 {name=p2 lab=rst}
C {devices/iopin.sym} 150 -60 0 0 {name=p3 lab=VPWR}
C {devices/iopin.sym} 150 120 0 0 {name=p4 lab=VGND}
C {devices/opin.sym} 300 0 0 0 {name=p5 lab=sine_out[17:0]}
C {devices/opin.sym} 300 40 0 0 {name=p6 lab=sign}
C {devices/opin.sym} 300 80 0 0 {name=p7 lab=signB}
